# Keil uVision project EffectiveTrendsLEDDigital-ex.uvproj, settings and files
target Target 1 (MCS-51)
  device: 80/87C52 Intel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: EffectiveTrendsLEDDigital-ex +hex
  c flags: Optimize=8 SizeSpeed=1
  group STARTUP
    ./: STARTUP.A51
  group USER
    ../User/: main.c
  group DOC
    ../Doc/: readme.txt
