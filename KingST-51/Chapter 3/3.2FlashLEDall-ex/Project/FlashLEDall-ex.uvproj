# Keil uVision project FlashLEDall-ex.uvproj, settings and files
target Target 1 (MCS-51)
  device: 80/87C52 Intel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: FlashLEDall-ex +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51
  group User
    ../User/: main.c
  group Doc
    ../Doc/: readme.txt
